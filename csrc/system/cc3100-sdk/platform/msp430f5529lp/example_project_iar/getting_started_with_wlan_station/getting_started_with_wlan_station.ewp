# IAR project getting_started_with_wlan_station.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 400
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: _USE_CLI_
  ICC430.newCCIncludePaths: ..\..\; ..\..\..\..\simplelink\include; ..\..\..\..\simplelink\source; ..\..\..\..\examples\common; $TI_PRODUCTS_DIR$\msp\MSP430Ware_3_80_03_07\driverlib\driverlib\MSP430F5xx_6xx
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../../../examples/getting_started_with_wlan_station/: main.c
  group board
    ../../: board.c board.h
  group cli_uart
    ../../: cli_uart.c cli_uart.h
  group simplelink
    ../../: user.h
  group simplelink/include
    ../../../../simplelink/include/: device.h fs.h netapp.h netcfg.h simplelink.h socket.h trace.h wlan.h wlan_rx_filters.h
  group simplelink/source
    ../../../../simplelink/source/: device.c driver.c driver.h flowcont.c flowcont.h fs.c netapp.c netcfg.c nonos.c nonos.h objInclusion.h protocol.h socket.c spawn.c spawn.h wlan.c
  group spi
    ../../: spi.c spi.h
  group timer
    ../../: timer_tick.c timer_tick.h
    $TI_PRODUCTS_DIR$/msp/MSP430Ware_3_80_03_07/driverlib/driverlib/MSP430F5xx_6xx/: timer_a.c timer_a.h
  group uart
    ../../: uart.c uart.h
