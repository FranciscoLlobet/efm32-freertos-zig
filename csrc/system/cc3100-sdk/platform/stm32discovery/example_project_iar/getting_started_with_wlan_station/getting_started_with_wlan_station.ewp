# IAR project getting_started_with_wlan_station.ewp, settings and files
configuration STM32F4-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; USE_STM32F4_DISCO; _USE_CLI_
  ICCARM.CCIncludePath2: ..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Drivers\BSP\STM32F4-Discovery; ..\..\; ..\..\..\..\simplelink\include; ..\..\..\..\simplelink\source; ..\..\..\..\examples\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: getting_started_with_wlan_station.srec
  ILINK.IlinkOutputFile: getting_started_with_wlan_station.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Board
    ../../: board.c board.h
  group CLI
    ../../: cli_uart.c cli_uart.h
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F4-Discovery
    ../../Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c
  group Drivers/CMSIS
    ../../: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Example/EWARM
    ./: startup_stm32f407xx.s
  group Example/User
    ../../../../examples/getting_started_with_wlan_station/: main.c
    ../../: stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Simplelink
    ../../: user.h
  group Simplelink/Inc
    ../../../../simplelink/include/: device.h fs.h netapp.h netcfg.h simplelink.h socket.h trace.h wlan.h wlan_rx_filters.h
  group Simplelink/Src
    ../../../../simplelink/source/: device.c driver.c driver.h flowcont.c flowcont.h fs.c netapp.c netcfg.c nonos.c nonos.h objInclusion.h protocol.h socket.c spawn.c spawn.h wlan.c
  group SPI
    ../../: spi.c spi.h
  group Timer
    ../../: timer_tick.c timer_tick.h
