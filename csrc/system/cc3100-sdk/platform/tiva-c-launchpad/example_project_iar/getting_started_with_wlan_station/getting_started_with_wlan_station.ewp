# IAR project getting_started_with_wlan_station.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM=1; TARGET_IS_BLIZZARD_RA1=1; _USE_CLI_
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\simplelink\include; ..\..\..\..\simplelink\source; ..\..\..\..\examples\common; $TI_PRODUCTS_DIR$\TivaWare_C_Series-2.1.4.178
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: getting_started_with_wlan_station.srec
  ILINK.IlinkOutputFile: getting_started_with_wlan_station.out
  ILINK.IlinkIcfFile: TM4C123GH6.icf
  ILINK.IlinkAdditionalLibs: $TI_PRODUCTS_DIR$\TivaWare_C_Series-2.1.4.178\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../examples/getting_started_with_wlan_station/: main.c
    ./: startup_ewarm.c
  group board
    ../../: board.c board.h
  group cli_uart
    ../../: cli_uart.c cli_uart.h
  group simplelink
    ../../: user.h
  group simplelink/include
    ../../../../simplelink/include/: device.h fs.h netapp.h netcfg.h simplelink.h socket.h trace.h wlan.h wlan_rx_filters.h
  group simplelink/source
    ../../../../simplelink/source/: device.c driver.c driver.h flowcont.c flowcont.h fs.c netapp.c netcfg.c nonos.c nonos.h objInclusion.h protocol.h socket.c spawn.c spawn.h wlan.c
  group spi
    ../../: spi.c spi.h
  group timer
    ../../: timer_tick.c timer_tick.h
  group uart
    ../../: uart.c uart.h
